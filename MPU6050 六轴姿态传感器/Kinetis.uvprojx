# Keil uVision project Kinetis.uvprojx, settings and files
target MK60DN (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MK60DN512xxx10 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Kinetis +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MK60DN
  c include: .\Chip\inc;.\Startup\CoreSupport;.\Startup\DeviceSupport;.\User;.\Board
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x20000
  group User
    ./Chip/inc/: MK60_port_cfg.h
    ./User/: isr.c main.c
  group Board
    ./Board/: inv_mpu.c inv_mpu_dmp_motion_driver.c MK60_myiic.cpp MK60_mpu6050.c MK60_myspi.c MK60_oled.c
  group Chip
    ./Chip/src/: common.c misc.c MK60_adc.c MK60_cmt.c MK60_dac.c MK60_dma.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_pit.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_systick.c MK60_uart.c MK60_wdog.c
  group Startup
    ./Startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s startup_MK60F15.s
    ./Startup/DeviceSupport/: system_MK60.c
target MK60FX (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MK60FX512xxx15 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00080000) IROM2(0x10000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Kinetis +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MK60FX
  c include: .\Chip\inc;.\Startup\CoreSupport;.\Startup\DeviceSupport;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
